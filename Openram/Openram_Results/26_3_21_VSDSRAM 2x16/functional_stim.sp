* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/peepu/VSDSRAM_sky130/OpenRAM/technology/sky130A/models/corners/tt.sp"
.include "sram_2_16_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_2_16_sky130A din0_0 din0_1 a0_0 a0_1 a0_2 a0_3 CSB0 WEB0 clk0 dout0_0 dout0_1 vdd gnd sram_2_16_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f

* Important signals for debug
* bl: xsram_2_16_sky130a.xbank0.bl_0_0
* br: xsram_2_16_sky130a.xbank0.br_0_0
* s_en: xsram_2_16_sky130a.s_en
* q: xsram_2_16_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar: xsram_2_16_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 01  to  address 1100 (from port 0) during cycle 1 (20ns - 40ns)
*	Reading 01 from address 1100 (from port 0) during cycle 4 (80ns - 100ns)
*	Reading 01 from address 1100 (from port 0) during cycle 5 (100ns - 120ns)
*	Reading 01 from address 1100 (from port 0) during cycle 6 (120ns - 140ns)
*	Reading 01 from address 1100 (from port 0) during cycle 7 (140ns - 160ns)
*	Reading 01 from address 1100 (from port 0) during cycle 8 (160ns - 180ns)
*	Reading 01 from address 1100 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 01 from address 1100 (from port 0) during cycle 10 (200ns - 220ns)
*	Writing 11  to  address 0000 (from port 0) during cycle 11 (220ns - 240ns)
*	Writing 00  to  address 0110 (from port 0) during cycle 12 (240ns - 260ns)
*	Reading 00 from address 0110 (from port 0) during cycle 13 (260ns - 280ns)
*	Writing 10  to  address 1100 (from port 0) during cycle 14 (280ns - 300ns)
*	Reading 11 from address 0000 (from port 0) during cycle 15 (300ns - 320ns)
*	Writing 00  to  address 0110 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 10 from address 1100 (from port 0) during cycle 17 (340ns - 360ns)
*	Reading 00 from address 0110 (from port 0) during cycle 19 (380ns - 400ns)
*	Writing 11  to  address 0001 (from port 0) during cycle 20 (400ns - 420ns)
*	Writing 10  to  address 0001 (from port 0) during cycle 21 (420ns - 440ns)
*	Reading 11 from address 0000 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 10 from address 1100 (from port 0) during cycle 23 (460ns - 480ns)
*	Reading 10 from address 1100 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 10 from address 0001 (from port 0) during cycle 26 (520ns - 540ns)
*	Reading 00 from address 0110 (from port 0) during cycle 27 (540ns - 560ns)
*	Reading 10 from address 0001 (from port 0) during cycle 28 (560ns - 580ns)
*	Writing 01  to  address 1110 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 11 from address 0000 (from port 0) during cycle 30 (600ns - 620ns)
*	Reading 11 from address 0000 (from port 0) during cycle 31 (620ns - 640ns)
*	Reading 10 from address 1100 (from port 0) during cycle 32 (640ns - 660ns)
*	Reading 01 from address 1110 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 10 from address 0001 (from port 0) during cycle 34 (680ns - 700ns)
*	Writing 11  to  address 0101 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 00 from address 0110 (from port 0) during cycle 36 (720ns - 740ns)
*	Reading 10 from address 1100 (from port 0) during cycle 37 (740ns - 760ns)
*	Reading 10 from address 1100 (from port 0) during cycle 38 (760ns - 780ns)
*	Reading 10 from address 0001 (from port 0) during cycle 39 (780ns - 800ns)
*	Reading 10 from address 1100 (from port 0) during cycle 40 (800ns - 820ns)
*	Writing 10  to  address 0100 (from port 0) during cycle 41 (820ns - 840ns)
*	Writing 00  to  address 1010 (from port 0) during cycle 42 (840ns - 860ns)
*	Writing 01  to  address 1011 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 01 from address 1011 (from port 0) during cycle 44 (880ns - 900ns)
*	Reading 01 from address 1110 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 01 from address 1110 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 11 from address 0101 (from port 0) during cycle 49 (980ns - 1000ns)
*	Reading 01 from address 1011 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 11 from address 0101 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 10 from address 0001 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Writing 01  to  address 1101 (from port 0) during cycle 55 (1100ns - 1120ns)
*	Writing 10  to  address 0001 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Writing 00  to  address 1110 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Writing 10  to  address 0111 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Reading 00 from address 1110 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Writing 01  to  address 1100 (from port 0) during cycle 61 (1220ns - 1240ns)
*	Writing 10  to  address 0011 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Reading 01 from address 1100 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Writing 01  to  address 1100 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Writing 01  to  address 1011 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Reading 10 from address 0001 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Reading 11 from address 0000 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 00 from address 1110 (from port 0) during cycle 70 (1400ns - 1420ns)
*	Reading 10 from address 0111 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Reading 11 from address 0000 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Writing 11  to  address 1011 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 10 from address 0111 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Reading 11 from address 1011 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Writing 00  to  address 1011 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 11 from address 0000 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Writing 00  to  address 0101 (from port 0) during cycle 85 (1700ns - 1720ns)
*	Writing 00  to  address 0001 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Writing 00  to  address 1010 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Reading 01 from address 1100 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Writing 11  to  address 0011 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Writing 01  to  address 1111 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Writing 11  to  address 0011 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Writing 00  to  address 0010 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Writing 11  to  address 1101 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Writing 01  to  address 1100 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Reading 10 from address 0100 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Writing 01  to  address 0101 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 00 from address 1011 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Writing 00  to  address 0110 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Writing 00  to  address 1011 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Writing 01  to  address 0110 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Writing 11  to  address 0110 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Writing 00  to  address 1100 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Reading 01 from address 1111 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Reading 00 from address 0001 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Writing 11  to  address 0100 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Writing 11  to  address 1110 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Reading 00 from address 0010 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Writing 11  to  address 1101 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Writing 10  to  address 0010 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 11 from address 1110 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Writing 00  to  address 0110 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 11 from address 1101 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Reading 00 from address 1011 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Reading 10 from address 0111 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Writing 00  to  address 1100 (from port 0) during cycle 124 (2480ns - 2500ns)
*	Writing 10  to  address 1100 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Writing 01  to  address 1011 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Writing 11  to  address 1000 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Reading 11 from address 0000 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Reading 11 from address 1000 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Reading 11 from address 0100 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Writing 01  to  address 1110 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Reading 11 from address 0011 (from port 0) during cycle 137 (2740ns - 2760ns)
*	Writing 01  to  address 0101 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Reading 01 from address 1011 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Writing 11  to  address 1011 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Reading 10 from address 1100 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Reading 10 from address 0010 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Writing 10  to  address 1000 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Writing 01  to  address 0011 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Reading 10 from address 1000 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 11 from address 1101 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Writing 00  to  address 1010 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Writing 00  to  address 1000 (from port 0) during cycle 154 (3080ns - 3100ns)
*	Writing 10  to  address 1110 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 00 from address 0110 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 11 from address 1011 (from port 0) during cycle 159 (3180ns - 3200ns)
*	Reading 11 from address 1101 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Reading 11 from address 1101 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Writing 11  to  address 1101 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Writing 10  to  address 0010 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Writing 01  to  address 1101 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Writing 01  to  address 0100 (from port 0) during cycle 167 (3340ns - 3360ns)
*	Reading 00 from address 1000 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Writing 11  to  address 1011 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Reading 01 from address 0011 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Reading 01 from address 0100 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Reading 01 from address 1101 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Writing 10  to  address 1101 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Writing 11  to  address 1000 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Writing 01  to  address 0111 (from port 0) during cycle 179 (3580ns - 3600ns)
*	Reading 10 from address 1101 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Reading 01 from address 0101 (from port 0) during cycle 182 (3640ns - 3660ns)
*	Writing 10  to  address 1011 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 00 from address 0001 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Writing 01  to  address 1011 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Writing 00  to  address 1100 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Reading 01 from address 1111 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Reading 00 from address 1100 (from port 0) during cycle 190 (3800ns - 3820ns)
*	Reading 10 from address 1110 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Writing 10  to  address 0001 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Reading 10 from address 0001 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Writing 01  to  address 1111 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Writing 10  to  address 0110 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Writing 00  to  address 1111 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 11 from address 0000 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 10 from address 0110 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Writing 10  to  address 1011 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Reading 01 from address 0100 (from port 0) during cycle 201 (4020ns - 4040ns)
*	Writing 10  to  address 0101 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Idle during cycle 203 (4060ns - 4080ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 0), (740, 0), (760, 0), (780, 1), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 1), (4060, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 1), (260, 1), (280, 0), (300, 0), (320, 1), (340, 0), (360, 0), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 0), (2160, 1), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 0), (4040, 0), (4060, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 1), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 1), (560, 0), (580, 1), (600, 0), (620, 0), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 1), (820, 1), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 1), (1060, 1), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 0), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 0), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 0), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 0), (640, 1), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 1), (780, 0), (800, 1), (820, 0), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 1), (2280, 0), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 1), (60, 1), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 1), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 0), (1440, 1), (1460, 0), (1480, 1), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 0), (1240, 1), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 1), (2260, 0), (2280, 0), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 1), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 0), (4060, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 20n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
.meas tran Vdout0_0ck0 AVG v(dout0_0) FROM=99.8n TO=100.2n

.meas tran Vdout0_1ck0 AVG v(dout0_1) FROM=99.8n TO=100.2n

.meas tran Vdout0_0ck1 AVG v(dout0_0) FROM=119.8n TO=120.2n

.meas tran Vdout0_1ck1 AVG v(dout0_1) FROM=119.8n TO=120.2n

.meas tran Vdout0_0ck2 AVG v(dout0_0) FROM=139.8n TO=140.2n

.meas tran Vdout0_1ck2 AVG v(dout0_1) FROM=139.8n TO=140.2n

.meas tran Vdout0_0ck3 AVG v(dout0_0) FROM=159.8n TO=160.2n

.meas tran Vdout0_1ck3 AVG v(dout0_1) FROM=159.8n TO=160.2n

.meas tran Vdout0_0ck4 AVG v(dout0_0) FROM=179.8n TO=180.2n

.meas tran Vdout0_1ck4 AVG v(dout0_1) FROM=179.8n TO=180.2n

.meas tran Vdout0_0ck5 AVG v(dout0_0) FROM=199.8n TO=200.2n

.meas tran Vdout0_1ck5 AVG v(dout0_1) FROM=199.8n TO=200.2n

.meas tran Vdout0_0ck6 AVG v(dout0_0) FROM=219.8n TO=220.2n

.meas tran Vdout0_1ck6 AVG v(dout0_1) FROM=219.8n TO=220.2n

.meas tran Vdout0_0ck7 AVG v(dout0_0) FROM=279.8n TO=280.2n

.meas tran Vdout0_1ck7 AVG v(dout0_1) FROM=279.8n TO=280.2n

.meas tran Vdout0_0ck8 AVG v(dout0_0) FROM=319.8n TO=320.2n

.meas tran Vdout0_1ck8 AVG v(dout0_1) FROM=319.8n TO=320.2n

.meas tran Vdout0_0ck9 AVG v(dout0_0) FROM=359.8n TO=360.2n

.meas tran Vdout0_1ck9 AVG v(dout0_1) FROM=359.8n TO=360.2n

.meas tran Vdout0_0ck10 AVG v(dout0_0) FROM=399.8n TO=400.2n

.meas tran Vdout0_1ck10 AVG v(dout0_1) FROM=399.8n TO=400.2n

.meas tran Vdout0_0ck11 AVG v(dout0_0) FROM=459.8n TO=460.2n

.meas tran Vdout0_1ck11 AVG v(dout0_1) FROM=459.8n TO=460.2n

.meas tran Vdout0_0ck12 AVG v(dout0_0) FROM=479.8n TO=480.2n

.meas tran Vdout0_1ck12 AVG v(dout0_1) FROM=479.8n TO=480.2n

.meas tran Vdout0_0ck13 AVG v(dout0_0) FROM=519.8n TO=520.2n

.meas tran Vdout0_1ck13 AVG v(dout0_1) FROM=519.8n TO=520.2n

.meas tran Vdout0_0ck14 AVG v(dout0_0) FROM=539.8n TO=540.2n

.meas tran Vdout0_1ck14 AVG v(dout0_1) FROM=539.8n TO=540.2n

.meas tran Vdout0_0ck15 AVG v(dout0_0) FROM=559.8n TO=560.2n

.meas tran Vdout0_1ck15 AVG v(dout0_1) FROM=559.8n TO=560.2n

.meas tran Vdout0_0ck16 AVG v(dout0_0) FROM=579.8n TO=580.2n

.meas tran Vdout0_1ck16 AVG v(dout0_1) FROM=579.8n TO=580.2n

.meas tran Vdout0_0ck17 AVG v(dout0_0) FROM=619.8n TO=620.2n

.meas tran Vdout0_1ck17 AVG v(dout0_1) FROM=619.8n TO=620.2n

.meas tran Vdout0_0ck18 AVG v(dout0_0) FROM=639.8n TO=640.2n

.meas tran Vdout0_1ck18 AVG v(dout0_1) FROM=639.8n TO=640.2n

.meas tran Vdout0_0ck19 AVG v(dout0_0) FROM=659.8n TO=660.2n

.meas tran Vdout0_1ck19 AVG v(dout0_1) FROM=659.8n TO=660.2n

.meas tran Vdout0_0ck20 AVG v(dout0_0) FROM=679.8n TO=680.2n

.meas tran Vdout0_1ck20 AVG v(dout0_1) FROM=679.8n TO=680.2n

.meas tran Vdout0_0ck21 AVG v(dout0_0) FROM=699.8n TO=700.2n

.meas tran Vdout0_1ck21 AVG v(dout0_1) FROM=699.8n TO=700.2n

.meas tran Vdout0_0ck22 AVG v(dout0_0) FROM=739.8n TO=740.2n

.meas tran Vdout0_1ck22 AVG v(dout0_1) FROM=739.8n TO=740.2n

.meas tran Vdout0_0ck23 AVG v(dout0_0) FROM=759.8n TO=760.2n

.meas tran Vdout0_1ck23 AVG v(dout0_1) FROM=759.8n TO=760.2n

.meas tran Vdout0_0ck24 AVG v(dout0_0) FROM=779.8n TO=780.2n

.meas tran Vdout0_1ck24 AVG v(dout0_1) FROM=779.8n TO=780.2n

.meas tran Vdout0_0ck25 AVG v(dout0_0) FROM=799.8n TO=800.2n

.meas tran Vdout0_1ck25 AVG v(dout0_1) FROM=799.8n TO=800.2n

.meas tran Vdout0_0ck26 AVG v(dout0_0) FROM=819.8n TO=820.2n

.meas tran Vdout0_1ck26 AVG v(dout0_1) FROM=819.8n TO=820.2n

.meas tran Vdout0_0ck27 AVG v(dout0_0) FROM=899.8n TO=900.2n

.meas tran Vdout0_1ck27 AVG v(dout0_1) FROM=899.8n TO=900.2n

.meas tran Vdout0_0ck28 AVG v(dout0_0) FROM=939.8n TO=940.2n

.meas tran Vdout0_1ck28 AVG v(dout0_1) FROM=939.8n TO=940.2n

.meas tran Vdout0_0ck29 AVG v(dout0_0) FROM=959.8n TO=960.2n

.meas tran Vdout0_1ck29 AVG v(dout0_1) FROM=959.8n TO=960.2n

.meas tran Vdout0_0ck30 AVG v(dout0_0) FROM=999.8n TO=1000.2n

.meas tran Vdout0_1ck30 AVG v(dout0_1) FROM=999.8n TO=1000.2n

.meas tran Vdout0_0ck31 AVG v(dout0_0) FROM=1039.8n TO=1040.2n

.meas tran Vdout0_1ck31 AVG v(dout0_1) FROM=1039.8n TO=1040.2n

.meas tran Vdout0_0ck32 AVG v(dout0_0) FROM=1059.8n TO=1060.2n

.meas tran Vdout0_1ck32 AVG v(dout0_1) FROM=1059.8n TO=1060.2n

.meas tran Vdout0_0ck33 AVG v(dout0_0) FROM=1099.8n TO=1100.2n

.meas tran Vdout0_1ck33 AVG v(dout0_1) FROM=1099.8n TO=1100.2n

.meas tran Vdout0_0ck34 AVG v(dout0_0) FROM=1199.8n TO=1200.2n

.meas tran Vdout0_1ck34 AVG v(dout0_1) FROM=1199.8n TO=1200.2n

.meas tran Vdout0_0ck35 AVG v(dout0_0) FROM=1299.8n TO=1300.2n

.meas tran Vdout0_1ck35 AVG v(dout0_1) FROM=1299.8n TO=1300.2n

.meas tran Vdout0_0ck36 AVG v(dout0_0) FROM=1359.8n TO=1360.2n

.meas tran Vdout0_1ck36 AVG v(dout0_1) FROM=1359.8n TO=1360.2n

.meas tran Vdout0_0ck37 AVG v(dout0_0) FROM=1379.8n TO=1380.2n

.meas tran Vdout0_1ck37 AVG v(dout0_1) FROM=1379.8n TO=1380.2n

.meas tran Vdout0_0ck38 AVG v(dout0_0) FROM=1419.8n TO=1420.2n

.meas tran Vdout0_1ck38 AVG v(dout0_1) FROM=1419.8n TO=1420.2n

.meas tran Vdout0_0ck39 AVG v(dout0_0) FROM=1439.8n TO=1440.2n

.meas tran Vdout0_1ck39 AVG v(dout0_1) FROM=1439.8n TO=1440.2n

.meas tran Vdout0_0ck40 AVG v(dout0_0) FROM=1479.8n TO=1480.2n

.meas tran Vdout0_1ck40 AVG v(dout0_1) FROM=1479.8n TO=1480.2n

.meas tran Vdout0_0ck41 AVG v(dout0_0) FROM=1539.8n TO=1540.2n

.meas tran Vdout0_1ck41 AVG v(dout0_1) FROM=1539.8n TO=1540.2n

.meas tran Vdout0_0ck42 AVG v(dout0_0) FROM=1639.8n TO=1640.2n

.meas tran Vdout0_1ck42 AVG v(dout0_1) FROM=1639.8n TO=1640.2n

.meas tran Vdout0_0ck43 AVG v(dout0_0) FROM=1699.8n TO=1700.2n

.meas tran Vdout0_1ck43 AVG v(dout0_1) FROM=1699.8n TO=1700.2n

.meas tran Vdout0_0ck44 AVG v(dout0_0) FROM=1779.8n TO=1780.2n

.meas tran Vdout0_1ck44 AVG v(dout0_1) FROM=1779.8n TO=1780.2n

.meas tran Vdout0_0ck45 AVG v(dout0_0) FROM=1979.8n TO=1980.2n

.meas tran Vdout0_1ck45 AVG v(dout0_1) FROM=1979.8n TO=1980.2n

.meas tran Vdout0_0ck46 AVG v(dout0_0) FROM=2039.8n TO=2040.2n

.meas tran Vdout0_1ck46 AVG v(dout0_1) FROM=2039.8n TO=2040.2n

.meas tran Vdout0_0ck47 AVG v(dout0_0) FROM=2179.8n TO=2180.2n

.meas tran Vdout0_1ck47 AVG v(dout0_1) FROM=2179.8n TO=2180.2n

.meas tran Vdout0_0ck48 AVG v(dout0_0) FROM=2199.8n TO=2200.2n

.meas tran Vdout0_1ck48 AVG v(dout0_1) FROM=2199.8n TO=2200.2n

.meas tran Vdout0_0ck49 AVG v(dout0_0) FROM=2259.8n TO=2260.2n

.meas tran Vdout0_1ck49 AVG v(dout0_1) FROM=2259.8n TO=2260.2n

.meas tran Vdout0_0ck50 AVG v(dout0_0) FROM=2319.8n TO=2320.2n

.meas tran Vdout0_1ck50 AVG v(dout0_1) FROM=2319.8n TO=2320.2n

.meas tran Vdout0_0ck51 AVG v(dout0_0) FROM=2399.8n TO=2400.2n

.meas tran Vdout0_1ck51 AVG v(dout0_1) FROM=2399.8n TO=2400.2n

.meas tran Vdout0_0ck52 AVG v(dout0_0) FROM=2439.8n TO=2440.2n

.meas tran Vdout0_1ck52 AVG v(dout0_1) FROM=2439.8n TO=2440.2n

.meas tran Vdout0_0ck53 AVG v(dout0_0) FROM=2479.8n TO=2480.2n

.meas tran Vdout0_1ck53 AVG v(dout0_1) FROM=2479.8n TO=2480.2n

.meas tran Vdout0_0ck54 AVG v(dout0_0) FROM=2639.8n TO=2640.2n

.meas tran Vdout0_1ck54 AVG v(dout0_1) FROM=2639.8n TO=2640.2n

.meas tran Vdout0_0ck55 AVG v(dout0_0) FROM=2659.8n TO=2660.2n

.meas tran Vdout0_1ck55 AVG v(dout0_1) FROM=2659.8n TO=2660.2n

.meas tran Vdout0_0ck56 AVG v(dout0_0) FROM=2719.8n TO=2720.2n

.meas tran Vdout0_1ck56 AVG v(dout0_1) FROM=2719.8n TO=2720.2n

.meas tran Vdout0_0ck57 AVG v(dout0_0) FROM=2759.8n TO=2760.2n

.meas tran Vdout0_1ck57 AVG v(dout0_1) FROM=2759.8n TO=2760.2n

.meas tran Vdout0_0ck58 AVG v(dout0_0) FROM=2799.8n TO=2800.2n

.meas tran Vdout0_1ck58 AVG v(dout0_1) FROM=2799.8n TO=2800.2n

.meas tran Vdout0_0ck59 AVG v(dout0_0) FROM=2839.8n TO=2840.2n

.meas tran Vdout0_1ck59 AVG v(dout0_1) FROM=2839.8n TO=2840.2n

.meas tran Vdout0_0ck60 AVG v(dout0_0) FROM=2879.8n TO=2880.2n

.meas tran Vdout0_1ck60 AVG v(dout0_1) FROM=2879.8n TO=2880.2n

.meas tran Vdout0_0ck61 AVG v(dout0_0) FROM=2999.8n TO=3000.2n

.meas tran Vdout0_1ck61 AVG v(dout0_1) FROM=2999.8n TO=3000.2n

.meas tran Vdout0_0ck62 AVG v(dout0_0) FROM=3019.8n TO=3020.2n

.meas tran Vdout0_1ck62 AVG v(dout0_1) FROM=3019.8n TO=3020.2n

.meas tran Vdout0_0ck63 AVG v(dout0_0) FROM=3179.8n TO=3180.2n

.meas tran Vdout0_1ck63 AVG v(dout0_1) FROM=3179.8n TO=3180.2n

.meas tran Vdout0_0ck64 AVG v(dout0_0) FROM=3199.8n TO=3200.2n

.meas tran Vdout0_1ck64 AVG v(dout0_1) FROM=3199.8n TO=3200.2n

.meas tran Vdout0_0ck65 AVG v(dout0_0) FROM=3219.8n TO=3220.2n

.meas tran Vdout0_1ck65 AVG v(dout0_1) FROM=3219.8n TO=3220.2n

.meas tran Vdout0_0ck66 AVG v(dout0_0) FROM=3239.8n TO=3240.2n

.meas tran Vdout0_1ck66 AVG v(dout0_1) FROM=3239.8n TO=3240.2n

.meas tran Vdout0_0ck67 AVG v(dout0_0) FROM=3379.8n TO=3380.2n

.meas tran Vdout0_1ck67 AVG v(dout0_1) FROM=3379.8n TO=3380.2n

.meas tran Vdout0_0ck68 AVG v(dout0_0) FROM=3459.8n TO=3460.2n

.meas tran Vdout0_1ck68 AVG v(dout0_1) FROM=3459.8n TO=3460.2n

.meas tran Vdout0_0ck69 AVG v(dout0_0) FROM=3479.8n TO=3480.2n

.meas tran Vdout0_1ck69 AVG v(dout0_1) FROM=3479.8n TO=3480.2n

.meas tran Vdout0_0ck70 AVG v(dout0_0) FROM=3499.8n TO=3500.2n

.meas tran Vdout0_1ck70 AVG v(dout0_1) FROM=3499.8n TO=3500.2n

.meas tran Vdout0_0ck71 AVG v(dout0_0) FROM=3639.8n TO=3640.2n

.meas tran Vdout0_1ck71 AVG v(dout0_1) FROM=3639.8n TO=3640.2n

.meas tran Vdout0_0ck72 AVG v(dout0_0) FROM=3659.8n TO=3660.2n

.meas tran Vdout0_1ck72 AVG v(dout0_1) FROM=3659.8n TO=3660.2n

.meas tran Vdout0_0ck73 AVG v(dout0_0) FROM=3719.8n TO=3720.2n

.meas tran Vdout0_1ck73 AVG v(dout0_1) FROM=3719.8n TO=3720.2n

.meas tran Vdout0_0ck74 AVG v(dout0_0) FROM=3779.8n TO=3780.2n

.meas tran Vdout0_1ck74 AVG v(dout0_1) FROM=3779.8n TO=3780.2n

.meas tran Vdout0_0ck75 AVG v(dout0_0) FROM=3819.8n TO=3820.2n

.meas tran Vdout0_1ck75 AVG v(dout0_1) FROM=3819.8n TO=3820.2n

.meas tran Vdout0_0ck76 AVG v(dout0_0) FROM=3839.8n TO=3840.2n

.meas tran Vdout0_1ck76 AVG v(dout0_1) FROM=3839.8n TO=3840.2n

.meas tran Vdout0_0ck77 AVG v(dout0_0) FROM=3879.8n TO=3880.2n

.meas tran Vdout0_1ck77 AVG v(dout0_1) FROM=3879.8n TO=3880.2n

.meas tran Vdout0_0ck78 AVG v(dout0_0) FROM=3979.8n TO=3980.2n

.meas tran Vdout0_1ck78 AVG v(dout0_1) FROM=3979.8n TO=3980.2n

.meas tran Vdout0_0ck79 AVG v(dout0_0) FROM=3999.8n TO=4000.2n

.meas tran Vdout0_1ck79 AVG v(dout0_1) FROM=3999.8n TO=4000.2n

.meas tran Vdout0_0ck80 AVG v(dout0_0) FROM=4039.8n TO=4040.2n

.meas tran Vdout0_1ck80 AVG v(dout0_1) FROM=4039.8n TO=4040.2n

.TRAN 10p 4080n UIC
.TEMP 0
.OPTIONS POST=1 RUNLVL=4 PROBE
* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
